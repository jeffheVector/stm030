# Keil uVision project ZG.uvprojx, settings and files
target ZG (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F030K6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ZG +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F030x6,MOTOR485,DEBUG
  c include: ../Core/Inc;  ../Drivers/STM32F0xx_HAL_Driver/Inc;  ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;  ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application/MDK-ARM
    ./: startup_stm32f030x6.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c systick.c port_sys.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group GWTASK
    ../Core/Src/: gwtask_timer.c
    ../Core/Inc/: gwtask_timer.h
  group UTILS
    ../Core/Src/: utils.c mylist.c myque.c myarray.c
    ../Core/Inc/: mylist.h myque.h
  group MOTOR
    ../Core/Inc/: pwm.h motor.h
    ../Core/Src/: pwm.c motor.c
  group HDEP
    ../Core/Inc/: abmn.h
    ../Core/Src/: abmn.c
  group LCD
    ../Core/Inc/: lcdfont.h lcd.h
    ../Core/Src/: lcdfont.c lcd.c hdep_logo_48.c
  group 485
    ../Core/Inc/: addr.h 485.h
    ../Core/Src/: addr.c 485.c
  group START
    ../Core/Src/: start.c
    ../Core/Inc/: start.h
software components: CMSIS:CORE 5.4.0
